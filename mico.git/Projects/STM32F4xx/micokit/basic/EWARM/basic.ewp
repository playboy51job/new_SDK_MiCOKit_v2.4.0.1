# IAR project basic.ewp, settings and files
configuration MiCOKit-3165 (ARM)
  General.OGChipSelectEditMenu: STM32F411CE ST STM32F411CE
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Full.h
  ICCARM.CCDefines: USE_STDPERIPH_DRIVER; DEBUG; HSE_VALUE=26000000; MICOKIT_3165
  ICCARM.CCDiagSuppress: Pa050
  ICCARM.CCIncludePath2: ..\..\..\..\..\include; ..\..\..\..\..\MICO\system; ..\..\..\..\..\libraries\utilities; ..\..\..\..\..\MICO\security; ..\..\..\..\..\Board\MiCOKit-3165; ..\..\..\..\..\Platform\include; ..\..\..\..\..\Platform\Cortex-M4; ..\..\..\..\..\Platform\Cortex-M4\CMSIS; ..\..\..\..\..\Platform\MCU\STM32F4xx\peripherals; ..\..\..\..\..\Platform\MCU\STM32F4xx\peripherals\Libraries\STM32F4xx_StdPeriph_Driver\inc; ..\..\..\..\..\Platform\MCU\STM32F4xx\peripherals\Libraries; ..\..\..\..\..\Platform\Drivers\spi_flash; ..\..\..\..\..\include\FogCloud; ..\..\..\..\..\Platform\Drivers\MiCOKit_EXT; ..\..\..\..\..\Demos\micokit\basic; ..\..\..\..\..\Platform\Drivers
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: basic.bin
  ILINK.IlinkOutputFile: basic.out
  ILINK.IlinkIcfFile: ..\..\..\..\..\Board\MiCOKit-3165\micoLinkerForIAR.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration NUCLEO_F411RE (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: USE_STDPERIPH_DRIVER; DEBUG; HSE_VALUE=26000000; NUCLEO_F411RE
  ICCARM.CCIncludePath2: ..\..\..\..\..\include; ..\..\..\..\..\MICO\system; ..\..\..\..\..\libraries\utilities; ..\..\..\..\..\MICO\security; ..\..\..\..\..\Board\NUCLEO_F411RE; ..\..\..\..\..\Platform\include; ..\..\..\..\..\Platform\Cortex-M4; ..\..\..\..\..\Platform\Cortex-M4\CMSIS; ..\..\..\..\..\Platform\MCU\STM32F4xx\peripherals; ..\..\..\..\..\Platform\MCU\STM32F4xx\peripherals\Libraries\STM32F4xx_StdPeriph_Driver\inc; ..\..\..\..\..\Platform\MCU\STM32F4xx\peripherals\Libraries; ..\..\..\..\..\Platform\Drivers\spi_flash; ..\..\..\..\..\include\FogCloud; ..\..\..\..\..\Demos\micokit\basic; ..\..\..\..\..\Platform\Drivers
  ILINK.IlinkIcfFile: ..\..\..\..\..\Board\NUCLEO_F411RE\micoLinkerForIAR.icf
  group Application
    ../../../../../Demos/micokit/basic/: mico_config.h
  group Application/helloworld
    ../../../../../Demos/micokit/basic/helloworld/: helloworld.c
  group Application/http/http_client
    ../../../../../Demos/micokit/basic/http/http_client/: http_client.c
  group Application/json
    ../../../../../Demos/micokit/basic/json/: json_op.c
  group Application/micokit3165_hal
    ../../../../../Demos/micokit/basic/micokit3165_hal/: micokit3165_hal_demo.c
  group Application/nucleo411_stmems_hal
    ../../../../../Demos/micokit/basic/nucleo411_stmems_hal/: nucleo411_stmems_hal_demo.c
  group Application/os
    ../../../../../Demos/micokit/basic/os/: os_mutex.c os_queue.c os_sem.c os_thread.c os_timer.c
  group Application/tcpip
    ../../../../../Demos/micokit/basic/tcpip/: dns.c mdns.c tcp_client.c tcp_server.c udp_broadcast.c udp_unicast.c
  group Application/wifi
    ../../../../../Demos/micokit/basic/wifi/: wifi_easylink.c wifi_scan.c wifi_softap.c wifi_station.c
  group Board/MiCOKit-3165
    ../../../../../Board/MiCOKit-3165/: platform.c platform.h platform_config.h
  group Board/NUCLEO_F411RE
    ../../../../../Board/NUCLEO_F411RE/: platform.c platform.h platform_config.h
  group include
    ../../../../../include/: MICO.h
  group include/FogCloud
    ../../../../../include/FogCloud/: FogCloudService.h FogCloudServiceDef.h FogCloudUtils.h
  group Library/protocols/FogCloud
    ../../../../../libraries/protocols/fog_cloud/: FogCloud_cm4_debug.a FogCloud_cm4_release.a
  group Library/utilities
    ../../../../../libraries/utilities/: CheckSumUtils.c HTTPUtils.c RingBufferUtils.c SocketUtils.c StringUtils.c URLUtils.c
  group Library/utilities/json_c
    ../../../../../libraries/utilities/json_c/: arraylist.c debug.c json_object.c json_tokener.c json_util.c linkhash.c printbuf.c
  group MICO/core
    ../../../../../MICO/core/: mico_config.c mxchipWNet_cm4f_8801.a mxchipWNet_cm4f_sdio.a mxchipWNet_cm4f_spi.a
  group MICO/system
    ../../../../../MICO/system/: mico_system_init.c mico_system_monitor.c mico_system_notification.c mico_system_para_storage.c mico_system_power_daemon.c system_factory_test.c system_misc.c
  group MICO/system/command_console
    ../../../../../MICO/system/command_console/: mico_cli.c mico_cli.h
  group MICO/system/config_server
    ../../../../../MICO/system/config_server/: config_server.c config_server_menu.c
  group MICO/system/easylink
    ../../../../../MICO/system/easylink/: system_easylink.c system_easylink_delegate.c
  group MICO/system/mdns
    ../../../../../MICO/system/mdns/: mico_mdns.c mico_mdns.h
  group MICO/system/tftp_ota
    ../../../../../MICO/system/tftp_ota/: tftp.h tftp_ota.c tftp_ota.h tftpc.o
  group Platform/Cortex-M4
    ../../../../../Platform/Cortex-M4/: crt0_EWARM.c hardfault.c
  group Platform/Drivers/MFiAuth
    ../../../../../Platform/Drivers/MicoDriverMFiAuth/: MicoDriverMFiAuth.a
  group Platform/Drivers/MiCOKit-EXT
    ../../../../../Platform/Drivers/MiCOKit_EXT/: micokit_ext.c micokit_ext.h micokit_ext_def.h micokit_ext_mfg.c
  group Platform/Drivers/MiCOKit-EXT/sensors/apds9930
    ../../../../../Platform/Drivers/sensor/apds9930/: apds9930.c apds9930.h
  group Platform/Drivers/MiCOKit-EXT/sensors/dc_motor
    ../../../../../Platform/Drivers/motor/dc_motor/: dc_motor.c dc_motor.h
  group Platform/Drivers/MiCOKit-EXT/sensors/HTS221
    ../../../../../Platform/Drivers/sensor/HTS221/: hts221.c hts221.h
  group Platform/Drivers/MiCOKit-EXT/sensors/infrared_reflective
    ../../../../../Platform/Drivers/sensor/infrared_adc/: infrared_reflective.c infrared_reflective.h
  group Platform/Drivers/MiCOKit-EXT/sensors/key
    ../../../../../Platform/Drivers/keypad/gpio_button/: button.c button.h
  group Platform/Drivers/MiCOKit-EXT/sensors/lcd
    ../../../../../Platform/Drivers/display/VGM128064/: AsciiLib.c AsciiLib.h oled.c oled.h oledfont.h
  group Platform/Drivers/MiCOKit-EXT/sensors/light
    ../../../../../Platform/Drivers/sensor/light_adc/: light_sensor.c light_sensor.h
  group Platform/Drivers/MiCOKit-EXT/sensors/LPS25HB
    ../../../../../Platform/Drivers/sensor/LPS25HB/: lps25hb.c lps25hb.h
  group Platform/Drivers/MiCOKit-EXT/sensors/LSM9DS1
    ../../../../../Platform/Drivers/sensor/LSM9DS1/: lsm9ds1.h lsm9ds1_acc_gyr.c lsm9ds1_mag.c
  group Platform/Drivers/MiCOKit-EXT/sensors/rgb_led
    ../../../../../Platform/Drivers/rgb_led/P9813/: hsb2rgb_led.c hsb2rgb_led.h rgb_led.c rgb_led.h
  group Platform/Drivers/MiCOKit-EXT/sensors/temp_hum_sensor
    ../../../../../Platform/Drivers/MiCOKit_EXT/: temp_hum_sensor.c temp_hum_sensor.h
  group Platform/Drivers/MiCOKit-EXT/sensors/temp_hum_sensor/BME280
    ../../../../../Platform/Drivers/sensor/BME280/: bme280.c bme280.h bme280_user.c bme280_user.h
  group Platform/Drivers/MiCOKit-EXT/sensors/temp_hum_sensor/DHT11
    ../../../../../Platform/Drivers/sensor/DHT11/: DHT11.c DHT11.h
  group Platform/Drivers/MiCOKit-EXT/sensors/UVIS25
    ../../../../../Platform/Drivers/sensor/UVIS25/: uvis25.c uvis25.h
  group Platform/Drivers/SPI Flash
    ../../../../../Platform/Drivers/spi_flash/: spi_flash.c spi_flash_platform.c
  group Platform/Drivers/ST_stmems
    ../../../../../Platform/Drivers/MiCOKit_STmems/: MiCOKit_STmems.c MiCOKit_STmems.h MiCOKit_STmems_def.h
  group Platform/EWARM
    ../../../../../Platform/EWARM/: Retarget.c
  group Platform/MCU
    ../../../../../Platform/MCU/: mico_platform_common.c wlan_platform_common.c
  group Platform/MCU/STM32F4xx
    ../../../../../Platform/MCU/STM32F4xx/: platform_init.c
  group Platform/MCU/STM32F4xx/EWARM
    ../../../../../Platform/MCU/STM32F4xx/EWARM/: startup_stm32f411xe_IAR.s
  group Platform/MCU/STM32F4xx/Peripherals
    ../../../../../Platform/MCU/STM32F4xx/peripherals/: paltform_rtc.c platform_adc.c platform_flash.c platform_gpio.c platform_i2c.c platform_mcu_powersave.c platform_nano_second.c platform_pwm.c platform_rng.c platform_spi.c platform_uart.c platform_watchdog.c
  group Platform/MCU/STM32F4xx/Peripherals/Libraries
    ../../../../../Platform/MCU/STM32F4xx/peripherals/Libraries/: system_stm32f4xx.c
  group Platform/MCU/STM32F4xx/Peripherals/Libraries/STM32F4xx_StdPeriph_Driver
    ../../../../../Platform/MCU/STM32F4xx/peripherals/Libraries/STM32F4xx_StdPeriph_Driver/src/: misc.c stm32f4xx_adc.c stm32f4xx_can.c stm32f4xx_crc.c stm32f4xx_cryp.c stm32f4xx_cryp_aes.c stm32f4xx_cryp_des.c stm32f4xx_cryp_tdes.c stm32f4xx_dac.c stm32f4xx_dbgmcu.c stm32f4xx_dcmi.c stm32f4xx_dma.c stm32f4xx_dma2d.c stm32f4xx_exti.c stm32f4xx_flash.c stm32f4xx_flash_ramfunc.c stm32f4xx_gpio.c stm32f4xx_hash.c stm32f4xx_hash_md5.c stm32f4xx_hash_sha1.c stm32f4xx_i2c.c stm32f4xx_iwdg.c stm32f4xx_ltdc.c stm32f4xx_pwr.c stm32f4xx_rcc.c stm32f4xx_rng.c stm32f4xx_rtc.c stm32f4xx_sai.c stm32f4xx_sdio.c stm32f4xx_spi.c stm32f4xx_syscfg.c stm32f4xx_tim.c stm32f4xx_usart.c stm32f4xx_wwdg.c
  group Platform/MCU/STM32F4xx/Wi-Fi_Bus_Driver
    ../../../../../Platform/MCU/STM32F4xx/wlan_bus_driver/: wlan_bus_sdio.c wlan_bus_spi.c wlan_platform.c
